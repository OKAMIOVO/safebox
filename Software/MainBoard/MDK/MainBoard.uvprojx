# Keil uVision project MainBoard.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051QN20 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MainBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FUNC_LOG
  c include: ..\Driver\inc;..\Base;..\Device
  asm define: FUNC_LOG
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../Core/: main.c com_key_board.c password_manage.c motor.c com_other_sys.c battery.c buzzer.c close_test.c key_scan.c led.c vibration_test.c voice.c
  group Driver
    ../Driver/src/: adc.c adc_user.c clk.c elc.c flash.c flash_user.c gpio.c iica.c iica_user.c intp.c intp_user.c key.c key_user.c pcbz.c retarget.c rst.c rtc.c sci.c sci_user.c wdt.c wdt_user.c tim4.c tim4_user.c
  group Base
    ../Base/: base.c cal.c com.c log.c MultiTimer.c key_filter.c device.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
